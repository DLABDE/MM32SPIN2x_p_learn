# Keil uVision project MM32.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32SPIN27PS MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.4
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Device\CMSIS\KEIL_CORE;..\Device\MM32SPIN2xx_p_LIB\HAL_lib\inc;..\Device\MM32SPIN2xx_p_LIB\Include;..\USER;..\USER\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group SYSTEM
    ../Device/MM32SPIN2xx_p_LIB/Source/: system_MM32SPIN2xx_p.c
    ../Device/MM32SPIN2xx_p_LIB/Source/KEIL_StartAsm/: startup_MM32SPIN2xx_p.s
  group HAL_LIB
    ../Device/MM32SPIN2xx_p_LIB/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group USER
    ../USER/: main.c mm32spin2x_p_it.c
  group APP
    ../USER/APP/: delay.c usart.c wwdg.c ttf_oled.c mpu9250.c mpu9250_iic.c
  group DOC
    ../: 必读说明.txt
